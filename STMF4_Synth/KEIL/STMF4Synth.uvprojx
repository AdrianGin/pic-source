# Keil uVision project STMF4Synth.uvprojx, settings and files
target STM32F4 Synth (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: STMF4Synth +hex
  c flags: Optim=1
  c include: ..\FuncLib\ThirdPartyDrivers\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\FuncLib\ThirdPartyDrivers\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\FuncLib\ThirdPartyDrivers\Libraries\STM32_USB_OTG_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: main.c
  group ::CMSIS
    D:/Keil/ARM/PACK/ARM/CMSIS/3.20.3/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/STM32F429ZI/: RTE_Device.h startup_stm32f429x.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.0.0
